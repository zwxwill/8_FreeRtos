# Keil uVision project project.uvprojx, settings and files
target 200M (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,USE_OS_FREERTOS
  c include: ..\..\FreeRtos\include;..\..\FreeRtos\portable\RVDS\ARM_CM4F;..\..\User;..\..\User\app\inc;..\..\User\bsp\inc;..\..\User\srv\inc;..\..\User\test\inc;..\..\Libraries\CMSIS_CM3\CM3\CoreSupport;..\..\Libraries\CMSIS_CM3\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\Flash\Obj\project.sct
  group User
    ../../User/: main.c stm32f10x_it.c
  group User/App
    ../../User/app/src/: app.c app_test.c app_Led.c app_check.c
  group User/Bsp
    ../../User/bsp/src/: bsp.c bsp_led.c
  group MDK-ARM
    ../../Libraries/CMSIS_CM3/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../../User/: system_stm32f10x.c
  group FreeRtos/source
    ../../FreeRtos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRtos/Ports
    ../../FreeRtos/include/: FreeRTOSConfig.h
    ../../FreeRtos/portable/RVDS/ARM_CM3/: port.c
    ../../FreeRtos/portable/MemMang/: heap_4.c heap_6.c
    ../../FreeRtos/: readme.txt
  group Doc
    ../../Doc/: 01.开发环境说明.txt 02.模板.txt 03.内存管理.txt 04.GPIO分配表.txt 05.任务分配.txt 06.问题点.txt
software components: CMSIS:CORE 5.0.0
