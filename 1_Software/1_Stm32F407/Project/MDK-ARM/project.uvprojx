# Keil uVision project project.uvprojx, settings and files
target 200M (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_OS_FREERTOS
  c include: ..\..\FreeRtos\include;..\..\FreeRtos\portable\RVDS\ARM_CM4F;..\..\Libraries\STM32F4x7_ETH_Driver\inc;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\User;..\..\User\app\inc;..\..\User\bsp\inc;..\..\User\srv\inc;..\..\Libraries\LWIP\lwip-1.4.1\src\include;..\..\Libraries\LWIP\lwip-1.4.1\src\include\lwip;..\..\Libraries\LWIP\lwip-1.4.1\src\include\netif;..\..\Libraries\LWIP\lwip-1.4.1\src\include\ipv4;..\..\Libraries\LWIP\port\STM32F4x7;..\..\Libraries\LWIP\port\STM32F4x7\FreeRTOS;..\..\Libraries\LWIP\lwip-1.4.1\src\apps;..\..\Libraries\freemodbus\modbus\ascii;..\..\Libraries\freemodbus\modbus\include;..\..\Libraries\freemodbus\modbus\rtu;..\..\Libraries\freemodbus\modbus\tcp;..\..\Libraries\freemodbus\port;..\..\User\conf;..\..\User\test\inc;..\..\Libraries\paho.mqtt.embedded-c\MQTTPacket\src;..\..\Libraries\paho.mqtt.embedded-c\MQTTClient-FreeRtos;..\..\Libraries\EasyFlash-V4.0\easyflash\inc;..\..\Libraries\EasyLogger\easylogger\inc;..\..\Libraries\EasyLogger\easylogger\plugins\flash
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Flash\Obj\project.sct
  group User
    ../../User/: main.c stm32f4xx_it.c
  group User/App
    ../../User/app/src/: app.c app_check.c app_Led.c app_tcpip.c app_test.c app_debug.c
  group User/Bsp
    ../../User/bsp/inc/: bsp.h
    ../../User/bsp/src/: bsp.c bsp_led.c bsp_lan8720.c bsp_uart.c bsp_ds3231.c bsp_i2c_gpio.c bsp_ad7606.c bsp_di.c bsp_do.c bsp_flash.c bsp_rs485.c bsp_sram.c bsp_tim.c bsp_dm9k.c
  group User/Srv
    ../../User/srv/src/: srv_rs485cfg.c srv_timer.c srv_netconf.c srv_printf.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
    ../../Libraries/STM32F4x7_ETH_Driver/inc/: stm32f4x7_eth_conf.h
  group CMSIS
    ../../User/: system_stm32f4xx.c
  group FreeRtos/source
    ../../FreeRtos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRtos/Ports
    ../../FreeRtos/include/: FreeRTOSConfig.h
    ../../FreeRtos/portable/RVDS/ARM_CM4F/: port.c
    ../../FreeRtos/portable/MemMang/: heap_6.c heap_4.c
    ../../FreeRtos/: FreeRTOSHook.c readme.txt
  group Lwip/Src
    ../../Libraries/LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../Libraries/LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../Libraries/LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../Libraries/LWIP/lwip-1.4.1/src/netif/: etharp.c
  group Lwip/Port
    ../../Libraries/LWIP/port/STM32F4x7/FreeRTOS/: lwipopts.h ethernetif.c dm9k_ethernetif.c sys_arch.c
  group Lwip/Apps
    ../../Libraries/LWIP/lwip-1.4.1/src/apps/mqtt/: mqtt.c
    ../../Libraries/LWIP/lwip-1.4.1/src/apps/netio/: netio.c
    ../../Libraries/LWIP/lwip-1.4.1/src/apps/sntp/: sntp.c
  group paho-mqtt
    ../../Libraries/paho.mqtt.embedded-c/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    ../../Libraries/paho.mqtt.embedded-c/MQTTClient-FreeRtos/: paho_mqtt_pipe.c
  group FM/modbus
    ../../Libraries/freemodbus/modbus/ascii/: mbascii.c
    ../../Libraries/freemodbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../../Libraries/freemodbus/modbus/rtu/: mbcrc.c mbrtu.c
    ../../Libraries/freemodbus/modbus/tcp/: mbtcp.c
    ../../Libraries/freemodbus/modbus/: mb.c
  group FM/port
    ../../Libraries/freemodbus/port/: portevent.c portserial.c porttimer.c porttcp.c portother.c port.c
    ../../Libraries/freemodbus/modbus/include/: mbconfig.h
  group EasyFlash
    ../../Libraries/EasyFlash-V4.0/easyflash/inc/: ef_cfg.h
    ../../Libraries/EasyFlash-V4.0/easyflash/src/: easyflash.c ef_utils.c ef_log.c ef_env.c
    ../../Libraries/EasyFlash-V4.0/easyflash/port/: ef_port.c
  group EasyLogger
    ../../Libraries/EasyLogger/easylogger/inc/: elog_cfg.h
    ../../Libraries/EasyLogger/easylogger/plugins/flash/: elog_flash_cfg.h elog_flash.c elog_flash_port.c
    ../../Libraries/EasyLogger/easylogger/src/: elog.c elog_utils.c elog_async.c elog_buf.c
    ../../Libraries/EasyLogger/easylogger/port/: elog_port.c
  group Test
    ../../User/test/src/: test_tcp.c test_modbus.c test_stackoverflow.c test_udp.c test_netio.c test_mqtt.c test_rs485.c test_task.c test_paho-mqtt.c test_elog.c test_eflash.c test_rawtcpclient.c
  group Doc
    ../../Doc/: 01.开发环境说明.txt 02.模板.txt 03.内存管理.txt 04.GPIO分配表.txt 05.任务分配.txt 06.问题点.txt
software components: CMSIS:CORE 5.0.0
